# Keil uVision project Temporary.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temporary +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\SYSTEM;.\FreeRTOS;.\Librarery;.\Hadrware;.\App;.\FATFS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c User.c Var.h
  group Librarery
    ./Librarery/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group FreeRTOS
    ./FreeRTOS/: heap_4.c list.c port.c tasks.c timers.c
  group SYSTEM
    ./SYSTEM/: System_Config.c core_cm3.c startup_stm32f10x_md.s
  group App
    ./App/: DTH11.c Encrypt.c GUI.c Graph.c
  group Hardware
    ./Hadrware/: LED.c USART2.c USART1.c Timer.c LCD.c ADC.c
